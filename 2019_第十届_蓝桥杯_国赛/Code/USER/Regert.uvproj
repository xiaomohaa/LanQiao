# Keil uVision project Regert.uvproj, settings and files
target Regert (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Regert +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/: display.c ds18b20.c iic.c key.c sonic.c
  group SYSTEM
    ../SYSTEM/: sys.c
