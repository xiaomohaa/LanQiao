# Keil uVision project temperature.uvproj, settings and files
target Temperature (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: temperature +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC
  group HARDWARE
    ../HARDWARE/: display.c ds18b20.c key.c iic.c
  group SYSTEM
    ../SYSTEM/: sys.c
  group USER
    ./: main.c
