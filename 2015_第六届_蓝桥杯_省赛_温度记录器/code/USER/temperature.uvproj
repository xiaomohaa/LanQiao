# Keil uVision project temperature.uvproj, settings and files
target temperature (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: temperature +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC
  group HARDWARE
    ../HARDWARE/: display.c key.c ds18b20.c ds1302.c
  group SYSTEM
    ../SYSTEM/: sys.c
  group USER
    ./: main.c
