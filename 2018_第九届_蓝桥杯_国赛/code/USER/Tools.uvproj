# Keil uVision project Tools.uvproj, settings and files
target Tools (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Tools +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC
  group HARDWARE
    ../HARDWARE/: display.c ds18b20.c iic.c key.c
  group SYSTEM
    ../SYSTEM/: sys.c
  group USER
    ./: main.c
