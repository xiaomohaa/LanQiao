# Keil uVision project watering.uvproj, settings and files
target Watering (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: watering +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC
  group HARDWARE
    ../HARDWARE/: ds1302.c iic.c key.c display.c
  group SYSTEM
    ../SYSTEM/: sys.c
  group USER
    ./: main.c
